V2 NET3 NET4 SINE ( 0 6 90hz 0.0S 0 )
V1 NET0 NET1 SINE ( 0 5 60hz 0.0S 0 )
R1 NET1 NET0 2.0K
R2 NET3 NET4 2.0K
C1 NET3 NET0 5.0KF
C2 NET4 NET1 5.0KF
