V1 0 Net1 SINE ( 0 5 10Hz 0s )
R1 Net1 Net2 10
L1 Net2 Net3 10H
C1 Net3 0 10F
