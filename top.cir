R1 NET2 NET0 2.2K
R2 NET3 NET4 2.2K
R3 NET4 NET3 2.2K
V1 NET2 NET0 SINE ( 0F 5MEG 60hz 0.0S 0 )
