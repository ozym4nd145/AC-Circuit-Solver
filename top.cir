R1 Net1 0 10K
C1 Net0 Net1 100NF
L1 Net0 0 10NH
R2 Net0 0 1F
C2 Net0 0 10MegF
I1 Net0 0 jhg SINE ( 0 1 10Khz 0.0S  0 )
