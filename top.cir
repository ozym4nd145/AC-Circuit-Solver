V1 0 Net1 SINE ( 0 5 10Hz 0s )
R1 Net1 Net2 10K
L1 Net2 Net3 10KH
C1 Net3 0 10KF
