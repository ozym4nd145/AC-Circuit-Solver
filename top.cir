R1 net0 net1 10
R2 net3 net2 10K
R3 net0 net3 10
R4 net0 net4 10
L net0 net5 10
