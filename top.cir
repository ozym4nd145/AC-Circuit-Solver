R1 NET2 NET3 2.2K
C1 NET3 0 1UF
V1 NET2 NET1 SINE ( 0 5 60hz 0.0S 0 )
V2 NET1 0 SINE ( 0 5 90hz 0.0S 0 )
